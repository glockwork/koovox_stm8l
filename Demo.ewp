# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.srec
  ILINK.IlinkOutputFile: Koovox.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
configuration Koovox (STM8, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: koovox.bin
  group StdPeriph_Driver/inc
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_conf.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_it.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_usart.h
  group StdPeriph_Driver/src
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_usart.c
  group User/inc
    User/inc/: koovox_const_seat.h koovox_hb_sensor.h koovox_head_action.h koovox_lis3dh_sensor.h koovox_message_handle.h koovox_neck_protect.h koovox_step_count.h koovox_uart.h
  group User/src
    User/src/: koovox_const_seat.c koovox_hb_sensor.c koovox_head_action.c koovox_lis3dh_sensor.c koovox_message_handle.c koovox_neck_protect.c koovox_step_count.c koovox_uart.c main.c
